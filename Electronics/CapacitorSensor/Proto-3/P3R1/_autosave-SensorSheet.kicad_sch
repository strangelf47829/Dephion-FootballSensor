File: Electronics/CapacitorSensor/Proto-3/P3R1/_autosave-SensorSheet.kicad_sch (KiCad schematic)
At the start: 388 parts

Commit message: Moare
Parts:
- gave numbers to parts that had none: 367
